# Keil uVision project STM32G474_RTThread.uvprojx, settings and files
target STM32G474_RTThread_Safe (6240000::V6.24::ARMCLANG)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") CLOCK(170000000) ELITTLE
  output: STM32G474_RTThread_Safe +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: STM32G474xx;APP_USE_RTTHREAD;HSE_VALUE=8000000
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m4 -mthumb -mfloat-abi=soft -Oz -Wno-unused-parameter
  c include: .\;.\Core\Inc;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32G4xx\Include;.\third_party\rt-thread\include;.\third_party\rt-thread\libcpu\arm\cortex-m4
  asm include: .\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\STM32G474_RTThread.sct
  link misc: --diag_suppress L6305
  group Application
    ./: main.c power_control.c power_control.h stm32g474_bare.h STM32G474_RTThread.sct
  group Board Safety
    ./Core/Src/: board_hrtim.c board_clock.c board_fast_adc.c board_safety.c rt_board.c board_fault_handlers.c board_uart.c board_cal_store.c
    ./Core/Inc/: board_hrtim.h board_clock.h board_fast_adc.h board_safety.h board_config.h board_uart.h board_cal_store.h
  group CMSIS Device
    ./Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: startup_stm32g474xx.s system_stm32g4xx.c
    ./Drivers/CMSIS/Device/ST/STM32G4xx/Include/: stm32g474xx.h stm32g4xx.h
  group RT-Thread Configuration
    ./: rtconfig.h
  group RT-Thread Kernel
    ./third_party/rt-thread/src/: clock.c idle.c ipc.c irq.c kservice.c object.c scheduler.c thread.c timer.c components.c
  group RT-Thread Cortex-M4 Port
    ./third_party/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
